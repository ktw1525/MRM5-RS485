# Repository ktw1525/MRM5-RS485

## KiCad design MRM5-tester/MRM5-tester.kicad_pcb

Parts:
C1: 1u; C_0603_1608Metric
C2: 100n; C_0603_1608Metric
IC1: STM32G051F8P6; SOP65P640X120-20N; Manufacturer_Part_Number STM32G051F8P6; Mouser Part Number 511-STM32G051F8P6
LED1, LED2, LED3, LED4: LED_5mm; LED_1206_3216Metric
Q1, Q2, Q3, Q4: SMMBT3906LT3G; SOT95P237X125-3N; Manufacturer_Part_Number MMBT3906-TP; Mouser Part Number 833-MMBT3906-TP
R1, R3, R5, R7: 1k; R_0402_1005Metric
R2, R4, R6, R8: 330; R_0402_1005Metric
Symbol1: ktw07182@gmail.com; ktw07182_logo

Connections:
/analog/1V6: IC1.8 (PA1); also elsewhere on the board
/analog/3V3: C1.2, C2.2, IC1.4 (VDD/VDDA), Q1.2 (E), Q2.2 (E), Q3.2 (E), Q4.2 (E); also elsewhere on the board
/analog/Z_IFlag: IC1.12 (PA5), R7.1; also elsewhere on the board
/analog/Z_TFlag: IC1.13 (PA6), R5.1; also elsewhere on the board
/analog/Zfreed: IC1.9 (PA2); also elsewhere on the board
/analog/sigV: IC1.7 (PA0); also elsewhere on the board
/analog/sigZ: IC1.11 (PA4); also elsewhere on the board
/interface/PUSH_BTN: IC1.2 (PB9/PC14-OSC32_IN); also elsewhere on the board
/interface/STLINK_CLK: IC1.19 (PA15/PA14-BOOT0); also elsewhere on the board
/interface/STLINK_DIO: IC1.18 (PA13); also elsewhere on the board
/interface/STLINK_RST: IC1.6 (PF2-NRST); also elsewhere on the board
/interface/SUSPEND: IC1.3 (PC15-OSC32_OUT); also elsewhere on the board
/interface/SYNC: IC1.10 (PA3); also elsewhere on the board
/interface/UART_CTS: IC1.17 (PA12[PA10]); also elsewhere on the board
/interface/UART_RTS: IC1.16 (PA11[PA9]); also elsewhere on the board
/interface/UART_RXD: IC1.20 (PB3/PB4/PB5/PB6); also elsewhere on the board
/interface/UART_TXD: IC1.1 (PB7/PB8); also elsewhere on the board
/mcu/1V6_IFlag: IC1.14 (PA7), R3.1; also elsewhere on the board
/mcu/1V6_TFlag: IC1.15 (PB0/PB1/PB2/PA8), R1.1; also elsewhere on the board
GND: C1.1, C2.1, IC1.5 (VSS/VSSA), R2.2, R4.2, R6.2, R8.2; also elsewhere on the board
unnamed: LED1.2 (A), Q1.3 (C)
unnamed: LED1.1 (K), R2.1
unnamed: LED2.2 (A), Q2.3 (C)
unnamed: LED2.1 (K), R4.1
unnamed: LED3.2 (A), Q3.3 (C)
unnamed: LED3.1 (K), R6.1
unnamed: LED4.2 (A), Q4.3 (C)
unnamed: LED4.1 (K), R8.1
unnamed: Q1.1 (B), R1.2
unnamed: Q2.1 (B), R3.2
unnamed: Q3.1 (B), R5.2
unnamed: Q4.1 (B), R7.2

Parts:
C3, C5: 4.7u; C_0603_1608Metric
C4, C6: 100n; C_0603_1608Metric
D1: CD143A-SR05; SOT-143_Handsoldering
J1, J2, J3, J6, J7: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical; Part Number 1-0201FBV0T
J4: PINHD_2x5_Female; PinSocket_2x05_P2.54mm_Vertical
J5: GSB1C41110SSHR; Manufacturer_Part_Number GSB1C41110SSHR
J8: PJ-037AH; PJ037AH; Manufacturer_Part_Number PJ-037AH; Mouser Part Number 490-PJ-037AH
LED5, LED6, LED7: LED_5mm; LED_1206_3216Metric
P1, P2: PAD_Hole_D2mm
Q5, Q6: SMMBT3906LT3G; SOT95P237X125-3N; Manufacturer_Part_Number MMBT3906-TP; Mouser Part Number 833-MMBT3906-TP
R9: 22.1k; R_0402_1005Metric
R10: 47.5k; R_0402_1005Metric
R11, R12, R14: 1k; R_0402_1005Metric
R13, R15, R16: 330; R_0402_1005Metric
SW1, SW2, SW3: TL3302AF260QG
U1: CP2102N-A02-GQFN20; CP2102NA02GQFN20

Connections:
/analog/1V6: J1.1, J2.1; also elsewhere on the board
/analog/3V3: J4.9, J4.10, LED7.2 (A), Q5.2 (E), Q6.2 (E); also elsewhere on the board
/analog/PT1: J2.2; also elsewhere on the board
/analog/PT1_bot: J6.1; also elsewhere on the board
/analog/PT2_bot: J6.2; also elsewhere on the board
/analog/V2p: J1.2; also elsewhere on the board
/interface/5V: J3.2, J4.3; also elsewhere on the board
/interface/5V_bot: J7.2, J8.1; also elsewhere on the board
/interface/GND_bot: J7.1, J8.2; also elsewhere on the board
/interface/PUSH_BTN: SW2.2; also elsewhere on the board
/interface/STLINK_CLK: J4.6; also elsewhere on the board
/interface/STLINK_DIO: J4.8; also elsewhere on the board
/interface/STLINK_RST: J4.4, SW1.2; also elsewhere on the board
/interface/SUSPEND: U1.11 (~SUSPEND); also elsewhere on the board
/interface/SYNC: SW3.2; also elsewhere on the board
/interface/UART_CTS: U1.15 (~CTS); also elsewhere on the board
/interface/UART_RTS: U1.16 (~RTS); also elsewhere on the board
/interface/UART_RXD: J4.7, U1.17 (RXD); also elsewhere on the board
/interface/UART_TXD: J4.5, U1.18 (TXD); also elsewhere on the board
/interface/Vn_h: P2.1; also elsewhere on the board
/interface/Vp_h: P1.1; also elsewhere on the board
GND: C3.1, C4.1, C5.1, C6.1, D1.1 (VN), J3.1, J4.1, J4.2, J5.A1 (GND_1), J5.A12 (GND_2), J5.MP1, J5.MP2, J5.MP3, J5.MP4, R10.1, R13.2, R15.2, R16.2, SW1.1, SW2.1, SW3.1, U1.3 (GND), U1.12 (GND), U1.21 (GND); also elsewhere on the board
unnamed: D1.2 (L1), J5.A6 (DP1), J5.B6 (DP2), U1.4 (D+)
unnamed: D1.3 (L2), J5.A7 (DN1), J5.B7 (DN2), U1.5 (D-)
unnamed: C3.2, C4.2, D1.4 (L3), J5.A4 (VBUS_1), J5.A9 (VBUS_2), R9.2, R11.2, U1.7 (VREGIN)
unnamed: LED5.2 (A), Q5.3 (C)
unnamed: LED5.1 (K), R13.1
unnamed: LED6.2 (A), Q6.3 (C)
unnamed: LED6.1 (K), R15.1
unnamed: LED7.1 (K), R16.1
unnamed: Q5.1 (B), R12.1
unnamed: Q6.1 (B), R14.1
unnamed: R9.1, R10.2, U1.8 (VBUS)
unnamed: C5.2, C6.2, U1.6 (VDD)
unnamed: R11.1, U1.9 (~RST)
unnamed: R12.2, U1.19 (~RXT/GPIO.3)
unnamed: R14.2, U1.20 (~TXT/GPIO.2)

Notes on the sheet:
External exposed
외부로 노출되어야 함
Top
Bottom

Parts:
C19, C25: 10uF, 16V; C_0603_1608Metric
C20: X2-15B( 0.1uF / 275V); B32922X__18_X_5_; Manufacturer_Part_Number B32922X2104K000; Mouser Part Number 871-B32922X2104K000
C21, C26: 100n; C_0603_1608Metric
C22, C23, C24: 47u; C_1206_3216Metric
C27: 220uF 16V 105℃; C_Radial_D6.3mm_H11.0mm_P2.50mm
FL1: SS21V-R110100; SSHB10HSR11100; Manufacturer_Part_Number SSHB10HS-R11100; Mouser Part Number 80-SSHB10HS-R11100
IC4: LD1085D2T33R; Manufacturer_Part_Number LD1085D2T33R; Mouser Part Number 511-LD1085D2T33-TR
IC5: OPA567AIRHGT; QFN100P500X500X100-13N-D; Manufacturer_Part_Number OPA567AIRHGT; Mouser Part Number 595-OPA567AIRHGT
PS1: HLK-15M05C; HLK15M05C; Manufacturer_Part_Number HLK-15M05C
R29, R30, R31: 7.68k; R_0402_1005Metric
RT1: NTC10D-11; NTC10D11; Manufacturer_Part_Number NTC10D-11
RV1: MOV-10D391K; MOV10D391K; Manufacturer_Part_Number MOV-10D391K; Mouser Part Number 652-MOV-10D391K

Connections:
/analog/1V6: C24.1, C26.2, IC5.2 (V_O_1), IC5.3 (V_O_2), IC5.8 (-IN); also elsewhere on the board
/analog/3V3: C21.2, C22.1, C23.1, C25.1, IC4.4 (OUTPUT), IC5.1 (V+_1), IC5.12 (V+_2), R30.1; also elsewhere on the board
/interface/5V: C19.1, IC4.3 (INPUT); also elsewhere on the board
/interface/5V_bot: C27.1, PS1.4 (+V0); also elsewhere on the board
/interface/GND_bot: C27.2, PS1.3 (-V0); also elsewhere on the board
/interface/Vn_h: C20.1, FL1.2, RV1.1; also elsewhere on the board
/interface/Vp_h: RT1.1, RV1.2; also elsewhere on the board
/mcu/1V6_IFlag: IC5.7 (IFLAG); also elsewhere on the board
/mcu/1V6_TFlag: IC5.10 (TFLAG), IC5.11 (ENABLE); also elsewhere on the board
/power/FL1_in1_sh: C20.2, FL1.1, RT1.2
/power/FL1_out1_sh: FL1.4, PS1.1 (AC_1); also elsewhere on the board
/power/FL1_out2_sh: FL1.3, PS1.2 (AC_2); also elsewhere on the board
GND: C19.2, C21.1, C22.2, C23.2, C24.2, C25.2, C26.1, IC4.1 (GND), IC5.4 (V-_1), IC5.5 (V-_2), R29.2, R31.2; also elsewhere on the board
unnamed: IC5.9 (+IN), R29.1, R30.2
unnamed: IC5.6 (ISET), R31.1

Parts:
C7, C10, C11, C15: 100n; C_0603_1608Metric
C8: 10n; C_0603_1608Metric
C9, C12, C13, C16: 47u; C_1206_3216Metric
C14, C17: 15n; C_0603_1608Metric
C18: 82n; C_0603_1608Metric
D2: BAT54S; SOT95P240X120-3N; Manufacturer_Part_Number BAT54S; Mouser Part Number 512-BAT54S
IC2: OPA567AIRHGT; QFN100P500X500X100-13N-D; Manufacturer_Part_Number OPA567AIRHGT; Mouser Part Number 595-OPA567AIRHGT
IC3: OPA388IDBVR; SOT95P280X145-5N; Manufacturer_Part_Number OPA388IDBVR; Mouser Part Number 595-OPA388IDBVR
L1: 744770218; WE-PD_744770218; Manufacturer_Part_Number 744770218; Mouser Part Number 710-744770218
P3, P4: PAD_Hole_D2mm
R17, R18: 1k; R_0402_1005Metric
R19: 10k; R_0402_1005Metric
R20: 16.2k; R_0402_1005Metric
R21: 7.68k; R_0402_1005Metric
R22: 22; R_Axial_DIN0918_L18.0mm_D9.0mm_P22.86mm_Horizontal
R23: 2.37k; R_0402_1005Metric
R24, R26: 2.7k; R_0402_1005Metric
R25: 4.99k; R_0402_1005Metric
R27: 4.64k; R_0402_1005Metric
R28: 1MΩ 1W; RESAD1650W60L650D250; Manufacturer_Part_Number MBB02070C1004FCT00
T1: ZMPT107-1; ZMPT1071; Manufacturer_Part_Number ZMPT107-1
TP1: Z; TestPoint_Pad_D2.0mm
TP2: Vf; TestPoint_Pad_D2.0mm
TP3: V; TestPoint_Pad_D2.0mm
U2: ADA4500-2ACPZ; DFN-8-1EP_3x3mm_P0.5mm_EP1.66x2.38mm
VR1: PTD901-1215K-B103; PTD9011015FA203; Manufacturer_Part_Number PTD901-1015F-A203; Mouser Part Number 652-PTD901-1015FA203
VR2: PTD902-2015K-C504; PTD9022015KC504; Manufacturer_Part_Number PTD902-2015K-C504; Mouser Part Number 652-PTD902-2015KC504

Connections:
/analog/1V6: C7.1, C8.1, C9.2, C10.1, C11.1, C12.2, C13.1, C15.1, C16.2, C17.1, P4.1, R18.1, R27.1, U2.9 (PAD), VR1.2 (WIPER), VR2.R11 (CCW_1); also elsewhere on the board
/analog/3V3: C7.2, C9.1, C15.2, C16.1, D2.2 (K), IC2.1 (V+_1), IC2.12 (V+_2), IC3.5 (V+), U2.8 (V+); also elsewhere on the board
/analog/PT1: D2.3 (A/K), R26.2, R27.2; also elsewhere on the board
/analog/PT1_bot: T1.4; also elsewhere on the board
/analog/PT2_bot: T1.3; also elsewhere on the board
/analog/Signal_Input: R19.1, R24.2, R26.1
/analog/V2p: R17.1, VR1.1 (CCW); also elsewhere on the board
/analog/Vp_ssh: R28.2, T1.2
/analog/Z_IFlag: IC2.7 (IFLAG); also elsewhere on the board
/analog/Z_TFlag: IC2.10 (TFLAG), IC2.11 (ENABLE); also elsewhere on the board
/analog/Zfreed: IC2.2 (V_O_1), IC2.3 (V_O_2), IC2.8 (-IN), R22.1, TP1.1; also elsewhere on the board
/analog/sigV: C18.2, TP3.1, U2.6 (-), U2.7; also elsewhere on the board
/analog/sigZ: IC2.9 (+IN); also elsewhere on the board
/power/FL1_out1_sh: T1.1; also elsewhere on the board
/power/FL1_out2_sh: R28.1; also elsewhere on the board
GND: C10.2, C11.2, C12.1, C13.2, D2.1 (A), IC2.4 (V-_1), IC2.5 (V-_2), IC3.2 (V-), R21.1, U2.4 (V-); also elsewhere on the board
unnamed: C14.1, R19.2, R20.1
unnamed: C18.1, R23.2, R25.1
unnamed: IC2.6 (ISET), R21.2
unnamed: IC3.3 (+IN), R17.2, VR2.R12 (WIPER_1)
unnamed: IC3.4 (-IN), R18.2, VR2.R21 (CCW_2)
unnamed: IC3.1 (OUT), R24.1, VR2.R22 (WIPER_2)
unnamed: L1.1, R22.2
unnamed: L1.2, P3.1
unnamed: C8.2, R20.2, U2.3 (+)
unnamed: C14.2, R23.1, TP2.1, U2.1, U2.2 (-)
unnamed: C17.2, R25.2, U2.5 (+)

Board: 2 copper layers, 143.7 x 111.0 mm, 107 parts (69 on the bottom side), 74 nets.

## KiCad design MRM5-Sensor/MRM5-Sensor.kicad_pcb

Parts:
J1: 1989447; Manufacturer_Part_Number 1989447; Mouser Part Number 651-1989447
J2, J3, J4, J5: Conn_01x02_Socket; PinSocket_1x02_P2.54mm_Vertical
P1: AC_L; PAD_hole
P2: AC_N; PAD_hole
R1, R2: 604k; R_1206_3216Metric
R3: 5.49k; R_0402_1005Metric
R4: 100; R_0402_1005Metric
T1: ZMPT107-1; ZMPT1071; Manufacturer_Part_Number ZMPT107-1

Connections:
GND: J4.1, J5.1
unnamed: J2.1, R3.2, T1.3
unnamed: J2.2, R3.1, T1.4
unnamed: J1.2, J3.1, R4.2
unnamed: J1.1, J3.2, R4.1
unnamed: P1.1, R1.1
unnamed: P2.1, R2.1
unnamed: R1.2, T1.1
unnamed: R2.2, T1.2

Board: 2 copper layers, 50.0 x 25.0 mm, 12 parts (10 on the bottom side), 9 nets.

## KiCad design MRM5-RS485-pcb/MRM5-RS485-pcb.kicad_pcb

Parts:
C15, C17: 4.7u; C_0805_2012Metric_Pad1.15x1.40mm
C16, C18: 0.1u; C_0402_1005Metric
D1: SP0503BAHT; SOT-143
D2: LED-YELLOW; LED_0402_1005Metric
D3: LED-GREEN; LED_0402_1005Metric
D4: LED-WHITE; LED_0402_1005Metric
J1: Conn_01x05; PinSocket_1x05_P2.54mm_Vertical
J2, J3, J4, J6: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical; Part Number 1-0201FBV0T
J5: GSB1C41110SSHR; Manufacturer_Part_Number GSB1C41110SSHR
R18: 22.1k; R_0402_1005Metric
R19: 47.5k; R_0402_1005Metric
R20: 1k; R_0402_1005Metric
R21, R22, R23: 330; R_0402_1005Metric
U5: CP2102N-A02-GQFN20; CP2102NA02GQFN20

Connections:
+1V6: J3.1, J4.1; also elsewhere on the board
+3V3: D4.2 (A), J1.5; also elsewhere on the board
+5V: C15.2, C16.2, D1.2 (L1), J5.A4 (VBUS_1), J5.A9 (VBUS_2), J6.2, R18.2, R20.2, U5.7 (VREGIN); also elsewhere on the board
/Analog/Vp: J4.2; also elsewhere on the board
/Analog/ZCTp: J3.2; also elsewhere on the board
/F1: U5.18 (TXD); also elsewhere on the board
/F2: U5.17 (RXD); also elsewhere on the board
/F3: U5.16 (~RTS); also elsewhere on the board
/F4: U5.15 (~CTS); also elsewhere on the board
/F5: U5.11 (~SUSPEND); also elsewhere on the board
/F6: U5.13 (~WAKEUP); also elsewhere on the board
/Interface/SYNC: J2.2; also elsewhere on the board
/SW1: J1.2; also elsewhere on the board
/SW2: J1.3; also elsewhere on the board
/SW3: J1.4; also elsewhere on the board
GND: C15.1, C16.1, C17.1, C18.1, D1.1 (VN), J1.1, J2.1, J5.A1 (GND_1), J5.A12 (GND_2), J5.MP1, J5.MP2, J5.MP3, J5.MP4, J6.1, R19.1, R21.2, R22.2, R23.2, U5.3 (GND), U5.12 (GND), U5.21 (GND); also elsewhere on the board
unnamed: D1.3 (L2), J5.A7 (DN1), J5.B7 (DN2), U5.5 (D-)
unnamed: D1.4 (L3), J5.A6 (DP1), J5.B6 (DP2), U5.4 (D+)
unnamed: D2.2 (A), U5.19 (~RXT/GPIO.3)
unnamed: D2.1 (K), R21.1
unnamed: D3.2 (A), U5.20 (~TXT/GPIO.2)
unnamed: D3.1 (K), R22.1
unnamed: D4.1 (K), R23.1
unnamed: R18.1, R19.2, U5.8 (VBUS)
unnamed: C17.2, C18.2, U5.6 (VDD)
unnamed: R20.1, U5.9 (~RST)
